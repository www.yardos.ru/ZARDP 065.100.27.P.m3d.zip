# KOMPAS-3D part (ZARDP 065.100.27.P.m3d)

Model tree:
1. Операция без истории:1  (labels: C:\Program Files\ASCON\KOMPAS-3D V13\Sys\graphic.lyt)
